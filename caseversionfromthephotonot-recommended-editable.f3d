caseversionfromthephotonot-recommended-editable (Autodesk Fusion 360 design; units mm, degrees)
named bodies: "Case", "Cover", "Helper"